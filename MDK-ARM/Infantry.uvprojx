# Keil uVision project Infantry.uvprojx, settings and files
target Infantry (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/Inc;../Components/utils;../Components/drvices;../Components/algorithms;../Components/Comm;../Components/SoftwareTimer;../Application;../Application/gimbal;..\Application\gimbal_other
  asm include: ..\Core\Inc;../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group BSP
    ../BSP/Src/: bsp_can.c bsp_delay.c bsp_flash.c bsp_gpio.c bsp_i2c.c bsp_uart.c bsp_init.c
  group Components/algorithms
    ../Components/algorithms/: AHRS_middleware.c pid.c ramp.c user_lib.c AHRS.lib arm_cortexM4lf_math.lib kalman.c kalman_filter.c
  group Components/Comm
    ../Components/Comm/: comm_protocol.c crc.c referee_system.c user_protocol.c client_ui_base.c vision_protocol.c
  group Components/drvices
    ../Components/drvices/Buzzer/: buzzer.c
    ../Components/drvices/IMU/: BMI088driver.c BMI088Middleware.c imu_driver.c ist8310driver.c ist8310driver_middleware.c
    ../Components/drvices/Motor/: blocked.c motor.c
    ../Components/drvices/RemoteControl/: remote_control.c
    ../Components/drvices/RGB_Led/: rgb_led.c
  group Components/SoftwareTimer
    ../Components/SoftwareTimer/: soft_timer.c
  group Components/utils
    ../Components/utils/: fifo.c
  group Application
    ../Application/: app_init.c comm_task.c detect_task.c imu_task.c infantry_console.c start_task.c timer_task.c infantry_def.h
  group Application/gimbal
    ../Application/gimbal/: gimbal_app.c gimbal_function.c gimbal_task.c shoot_task.c
  group Application/chassis
    ../Application/chassis/: chassis_app.c chassis_function.c chassis_task.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/gimbal_other
    ../Application/gimbal_other/: gimbal_other_app.c gimbal_other_task.c shoot_other_task.c
software components: CMSIS:CORE 4.3.0
